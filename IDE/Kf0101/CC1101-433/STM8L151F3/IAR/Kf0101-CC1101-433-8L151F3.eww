<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Kf0101-CC1101-433-8L151F3.ewp</path>
    </project>
    <batchBuild />
</workspace>
