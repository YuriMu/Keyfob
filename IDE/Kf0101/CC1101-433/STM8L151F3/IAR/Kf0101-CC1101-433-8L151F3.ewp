# IAR project Kf0101-CC1101-433-8L151F3.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\..\..\..\CC1101\433; ..\..\..\..\..\CC1101; ..\..\..\..\..\STM8L151F3\1button; ..\..\..\..\..\STM8L151F3; ..\..\..\..\..\Var01; ..\..\..\..\..; ..\..\..\..\..\STM8L15x_StdPeriph_Driver\inc; ..\..\..\..\..\STM8L15x_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Kf0101-CC1101-433-8L151F3.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    ../../../../../STM8L151F3/1button/: bsp_buttons.c stm8l15x_it.c
    ../../../../../STM8L151F3/: bsp_sound.c bsp_system.c bsp_timer.c
    ../../../../../: buttons.c main.c pult.c sound.c
  group Doc
    ../../../../../: Notes.txt WorkNotes.txt
    ../../../../../../../Examples/STM8/Snippets/: Snippets.c
  group STM8L15x_StdPeriph_Driver
    ../../../../../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
